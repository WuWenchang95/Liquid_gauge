# Keil uVision project FlowPro.uvproj, settings and files
target CA51FX (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: ca51fx +hex
  c flags: Optimize=9
  group ca51f_config
    ./: ca51f_config.h
  group Source Files
    ./: main.c key.c Flowfunction.c TM1640.c buzzer.c
    ../../Library/Sources/: system_clock.c wdt.c flash.c delay.c uart.c
  group Lib
    ../../Library/Lib/: STARTUP.A51
